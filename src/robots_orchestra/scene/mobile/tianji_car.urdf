Commit message: update:已经初步可以实现1双臂预期效果

File: src/robots_orchestra/scene/mobile/tianji_car.urdf (robot description, URDF)
Before this commit: robot tianji_car, 5 links, 4 joints
Joints:
- joint joint_4: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0.3 0 0 rpy=0 0 0
